!!!! CIURCUIT !!!!
RaC n5 n1 {parRaC}
LaC n4 n5 {parLaC}
VbackemfCVAR n4 n3 PWL(0 0 1e-9 9.351436e-01)
Vprobe1 n2 n3 0
VgenVAR n6 0 PWL(0.000000e+00 1.500000e+01 1.000000e-06 1.500000e+01 2.000000e-06 1.500000e+01 3.000000e-06 1.500000e+01 4.000000e-06 1.500000e+01 5.000000e-06 1.500000e+01 6.000000e-06 1.500000e+01 7.000000e-06 1.500000e+01 8.000000e-06 1.500000e+01 9.000000e-06 1.500000e+01 1.000000e-05 1.500000e+01 1.100000e-05 1.500000e+01 1.200000e-05 1.500000e+01 1.300000e-05 1.500000e+01 1.400000e-05 1.500000e+01 1.500000e-05 1.500000e+01 1.600000e-05 1.500000e+01 1.700000e-05 1.500000e+01 1.800000e-05 1.500000e+01 1.900000e-05 1.500000e+01 2.000000e-05 1.500000e+01 2.100000e-05 1.500000e+01 2.200000e-05 1.500000e+01 2.300000e-05 1.500000e+01 2.400000e-05 1.500000e+01 2.500000e-05 1.500000e+01 2.600000e-05 1.500000e+01 2.700000e-05 1.500000e+01 2.800000e-05 1.500000e+01 2.900000e-05 1.500000e+01 3.000000e-05 1.500000e+01 3.100000e-05 1.500000e+01 3.200000e-05 1.500000e+01 3.300000e-05 1.500000e+01 3.400000e-05 1.500000e+01 3.500000e-05 1.500000e+01 3.600000e-05 1.500000e+01 3.700000e-05 1.500000e+01 3.800000e-05 1.500000e+01 3.900000e-05 1.500000e+01 4.000000e-05 1.500000e+01 4.100000e-05 1.500000e+01 4.200000e-05 1.500000e+01 4.300000e-05 1.500000e+01 4.400000e-05 1.500000e+01 4.500000e-05 1.500000e+01 4.600000e-05 1.500000e+01 4.700000e-05 1.500000e+01 4.800000e-05 1.500000e+01 4.900000e-05 1.500000e+01 5.000000e-05 1.500000e+01 5.100000e-05 1.500000e+01 5.200000e-05 1.500000e+01 5.300000e-05 1.500000e+01 5.400000e-05 1.500000e+01 5.500000e-05 1.500000e+01 5.600000e-05 1.500000e+01 5.700000e-05 1.500000e+01 5.800000e-05 1.500000e+01 5.900000e-05 1.500000e+01 6.000000e-05 1.500000e+01 6.100000e-05 1.500000e+01 6.200000e-05 1.500000e+01 6.300000e-05 1.500000e+01 6.400000e-05 1.500000e+01 6.500000e-05 1.500000e+01 6.600000e-05 1.500000e+01 6.700000e-05 1.500000e+01 6.800000e-05 1.500000e+01 6.900000e-05 1.500000e+01 7.000000e-05 1.500000e+01 7.100000e-05 1.500000e+01 7.200000e-05 1.500000e+01 7.300000e-05 1.500000e+01 7.400000e-05 1.500000e+01 7.500000e-05 1.500000e+01 7.600000e-05 1.500000e+01 7.700000e-05 1.500000e+01 7.800000e-05 1.500000e+01 7.900000e-05 1.500000e+01 8.000000e-05 1.500000e+01 8.100000e-05 1.500000e+01 8.200000e-05 1.500000e+01 8.300000e-05 1.500000e+01 8.400000e-05 1.500000e+01 8.500000e-05 1.500000e+01 8.600000e-05 1.500000e+01 8.700000e-05 1.500000e+01 8.800000e-05 1.500000e+01 8.900000e-05 1.500000e+01 9.000000e-05 1.500000e+01 9.100000e-05 1.500000e+01 9.200000e-05 1.500000e+01 9.300000e-05 1.500000e+01 9.400000e-05 1.500000e+01 9.500000e-05 1.500000e+01 9.600000e-05 1.500000e+01 9.700000e-05 1.500000e+01 9.800000e-05 1.500000e+01 9.900000e-05 1.500000e+01 1.000000e-04 1.500000e+01 1.010000e-04 1.500000e+01 1.020000e-04 1.500000e+01 1.030000e-04 1.500000e+01 1.040000e-04 1.500000e+01 1.050000e-04 1.500000e+01 1.060000e-04 1.500000e+01 1.070000e-04 1.500000e+01 1.080000e-04 1.500000e+01 1.090000e-04 1.500000e+01 1.100000e-04 1.500000e+01 1.110000e-04 1.500000e+01 1.120000e-04 1.500000e+01 1.130000e-04 1.500000e+01 1.140000e-04 1.500000e+01 1.150000e-04 1.500000e+01 1.160000e-04 1.500000e+01 1.170000e-04 1.500000e+01 1.180000e-04 1.500000e+01 1.190000e-04 1.500000e+01 1.200000e-04 1.500000e+01 1.210000e-04 1.500000e+01 1.220000e-04 1.500000e+01 1.230000e-04 1.500000e+01 1.240000e-04 1.500000e+01 1.250000e-04 1.500000e+01 1.260000e-04 1.500000e+01 1.270000e-04 1.500000e+01 1.280000e-04 1.500000e+01 1.290000e-04 1.500000e+01 1.300000e-04 1.500000e+01 1.310000e-04 1.500000e+01 1.320000e-04 1.500000e+01 1.330000e-04 1.500000e+01 1.340000e-04 1.500000e+01 1.350000e-04 1.500000e+01 1.360000e-04 1.500000e+01 1.370000e-04 1.500000e+01 1.380000e-04 1.500000e+01 1.390000e-04 1.500000e+01 1.400000e-04 1.500000e+01 1.410000e-04 1.500000e+01 1.420000e-04 1.500000e+01 1.430000e-04 1.500000e+01 1.440000e-04 1.500000e+01 1.450000e-04 1.500000e+01 1.460000e-04 1.500000e+01 1.470000e-04 1.500000e+01 1.480000e-04 1.500000e+01 1.490000e-04 1.500000e+01 1.500000e-04 1.500000e+01 1.510000e-04 1.500000e+01 1.520000e-04 1.500000e+01 1.530000e-04 1.500000e+01 1.540000e-04 1.500000e+01 1.550000e-04 1.500000e+01 1.560000e-04 1.500000e+01 1.570000e-04 1.500000e+01 1.580000e-04 1.500000e+01 1.590000e-04 1.500000e+01 1.600000e-04 1.500000e+01 1.610000e-04 1.500000e+01 1.620000e-04 1.500000e+01 1.630000e-04 1.500000e+01 1.640000e-04 1.500000e+01 1.650000e-04 1.500000e+01 1.660000e-04 1.500000e+01 1.670000e-04 1.500000e+01 1.680000e-04 1.500000e+01 1.690000e-04 1.500000e+01 1.700000e-04 1.500000e+01 1.710000e-04 1.500000e+01 1.720000e-04 1.500000e+01 1.730000e-04 1.500000e+01 1.740000e-04 1.500000e+01 1.750000e-04 1.500000e+01 1.760000e-04 1.500000e+01 1.770000e-04 1.500000e+01 1.780000e-04 1.500000e+01 1.790000e-04 1.500000e+01 1.800000e-04 1.500000e+01 1.810000e-04 1.500000e+01 1.820000e-04 1.500000e+01 1.830000e-04 1.500000e+01 1.840000e-04 1.500000e+01 1.850000e-04 1.500000e+01 1.860000e-04 1.500000e+01 1.870000e-04 1.500000e+01 1.880000e-04 1.500000e+01 1.890000e-04 1.500000e+01 1.900000e-04 1.500000e+01 1.910000e-04 1.500000e+01 1.920000e-04 1.500000e+01 1.930000e-04 1.500000e+01 1.940000e-04 1.500000e+01 1.950000e-04 1.500000e+01 1.960000e-04 1.500000e+01 1.970000e-04 1.500000e+01 1.980000e-04 1.500000e+01 1.990000e-04 1.500000e+01)
S1 n12 n6 n10 0 SW1
VSW1VAR n10 0 PWL(0.000000e+00 1.000000e+00 1.000000e-06 1.000000e+00 2.000000e-06 1.000000e+00 3.000000e-06 1.000000e+00 4.000000e-06 1.000000e+00 5.000000e-06 1.000000e+00 6.000000e-06 1.000000e+00 7.000000e-06 1.000000e+00 8.000000e-06 1.000000e+00 9.000000e-06 1.000000e+00 1.000000e-05 1.000000e+00 1.100000e-05 1.000000e+00 1.200000e-05 1.000000e+00 1.300000e-05 1.000000e+00 1.400000e-05 1.000000e+00 1.500000e-05 1.000000e+00 1.600000e-05 1.000000e+00 1.700000e-05 1.000000e+00 1.800000e-05 1.000000e+00 1.900000e-05 1.000000e+00 2.000000e-05 1.000000e+00 2.100000e-05 1.000000e+00 2.200000e-05 1.000000e+00 2.300000e-05 1.000000e+00 2.400000e-05 1.000000e+00 2.500000e-05 1.000000e+00 2.600000e-05 1.000000e+00 2.700000e-05 1.000000e+00 2.800000e-05 1.000000e+00 2.900000e-05 1.000000e+00 3.000000e-05 1.000000e+00 3.100000e-05 1.000000e+00 3.200000e-05 1.000000e+00 3.300000e-05 1.000000e+00 3.400000e-05 1.000000e+00 3.500000e-05 1.000000e+00 3.600000e-05 1.000000e+00 3.700000e-05 1.000000e+00 3.800000e-05 1.000000e+00 3.900000e-05 1.000000e+00 4.000000e-05 1.000000e+00 4.100000e-05 1.000000e+00 4.200000e-05 1.000000e+00 4.300000e-05 1.000000e+00 4.400000e-05 1.000000e+00 4.500000e-05 1.000000e+00 4.600000e-05 1.000000e+00 4.700000e-05 1.000000e+00 4.800000e-05 1.000000e+00 4.900000e-05 1.000000e+00 5.000000e-05 1.000000e+00 5.100000e-05 1.000000e+00 5.200000e-05 1.000000e+00 5.300000e-05 1.000000e+00 5.400000e-05 1.000000e+00 5.500000e-05 1.000000e+00 5.600000e-05 1.000000e+00 5.700000e-05 1.000000e+00 5.800000e-05 1.000000e+00 5.900000e-05 1.000000e+00 6.000000e-05 1.000000e+00 6.100000e-05 1.000000e+00 6.200000e-05 1.000000e+00 6.300000e-05 1.000000e+00 6.400000e-05 1.000000e+00 6.500000e-05 1.000000e+00 6.600000e-05 1.000000e+00 6.700000e-05 1.000000e+00 6.800000e-05 1.000000e+00 6.900000e-05 1.000000e+00 7.000000e-05 1.000000e+00 7.100000e-05 1.000000e+00 7.200000e-05 1.000000e+00 7.300000e-05 1.000000e+00 7.400000e-05 1.000000e+00 7.500000e-05 1.000000e+00 7.600000e-05 1.000000e+00 7.700000e-05 1.000000e+00 7.800000e-05 1.000000e+00 7.900000e-05 1.000000e+00 8.000000e-05 1.000000e+00 8.100000e-05 1.000000e+00 8.200000e-05 1.000000e+00 8.300000e-05 1.000000e+00 8.400000e-05 1.000000e+00 8.500000e-05 1.000000e+00 8.600000e-05 1.000000e+00 8.700000e-05 1.000000e+00 8.800000e-05 1.000000e+00 8.900000e-05 1.000000e+00 9.000000e-05 1.000000e+00 9.100000e-05 1.000000e+00 9.200000e-05 1.000000e+00 9.300000e-05 1.000000e+00 9.400000e-05 1.000000e+00 9.500000e-05 1.000000e+00 9.600000e-05 1.000000e+00 9.700000e-05 1.000000e+00 9.800000e-05 1.000000e+00 9.900000e-05 1.000000e+00 1.000000e-04 1.000000e+00 1.010000e-04 1.000000e+00 1.020000e-04 1.000000e+00 1.030000e-04 1.000000e+00 1.040000e-04 1.000000e+00 1.050000e-04 1.000000e+00 1.060000e-04 1.000000e+00 1.070000e-04 1.000000e+00 1.080000e-04 1.000000e+00 1.090000e-04 1.000000e+00 1.100000e-04 1.000000e+00 1.110000e-04 1.000000e+00 1.120000e-04 1.000000e+00 1.130000e-04 1.000000e+00 1.140000e-04 1.000000e+00 1.150000e-04 1.000000e+00 1.160000e-04 1.000000e+00 1.170000e-04 1.000000e+00 1.180000e-04 1.000000e+00 1.190000e-04 1.000000e+00 1.200000e-04 1.000000e+00 1.210000e-04 1.000000e+00 1.220000e-04 1.000000e+00 1.230000e-04 1.000000e+00 1.240000e-04 1.000000e+00 1.250000e-04 1.000000e+00 1.260000e-04 1.000000e+00 1.270000e-04 1.000000e+00 1.280000e-04 1.000000e+00 1.290000e-04 1.000000e+00 1.300000e-04 1.000000e+00 1.310000e-04 1.000000e+00 1.320000e-04 1.000000e+00 1.330000e-04 1.000000e+00 1.340000e-04 1.000000e+00 1.350000e-04 1.000000e+00 1.360000e-04 1.000000e+00 1.370000e-04 1.000000e+00 1.380000e-04 1.000000e+00 1.390000e-04 1.000000e+00 1.400000e-04 1.000000e+00 1.410000e-04 1.000000e+00 1.420000e-04 1.000000e+00 1.430000e-04 1.000000e+00 1.440000e-04 1.000000e+00 1.450000e-04 1.000000e+00 1.460000e-04 1.000000e+00 1.470000e-04 1.000000e+00 1.480000e-04 1.000000e+00 1.490000e-04 1.000000e+00 1.500000e-04 1.000000e+00 1.510000e-04 1.000000e+00 1.520000e-04 1.000000e+00 1.530000e-04 1.000000e+00 1.540000e-04 1.000000e+00 1.550000e-04 1.000000e+00 1.560000e-04 1.000000e+00 1.570000e-04 1.000000e+00 1.580000e-04 1.000000e+00 1.590000e-04 1.000000e+00 1.600000e-04 1.000000e+00 1.610000e-04 1.000000e+00 1.620000e-04 1.000000e+00 1.630000e-04 1.000000e+00 1.640000e-04 1.000000e+00 1.650000e-04 1.000000e+00 1.660000e-04 1.000000e+00 1.670000e-04 1.000000e+00 1.680000e-04 1.000000e+00 1.690000e-04 1.000000e+00 1.700000e-04 1.000000e+00 1.710000e-04 1.000000e+00 1.720000e-04 1.000000e+00 1.730000e-04 1.000000e+00 1.740000e-04 1.000000e+00 1.750000e-04 1.000000e+00 1.760000e-04 1.000000e+00 1.770000e-04 1.000000e+00 1.780000e-04 1.000000e+00 1.790000e-04 1.000000e+00 1.800000e-04 1.000000e+00 1.810000e-04 1.000000e+00 1.820000e-04 1.000000e+00 1.830000e-04 1.000000e+00 1.840000e-04 1.000000e+00 1.850000e-04 1.000000e+00 1.860000e-04 1.000000e+00 1.870000e-04 1.000000e+00 1.880000e-04 1.000000e+00 1.890000e-04 1.000000e+00 1.900000e-04 1.000000e+00 1.910000e-04 1.000000e+00 1.920000e-04 1.000000e+00 1.930000e-04 1.000000e+00 1.940000e-04 1.000000e+00 1.950000e-04 1.000000e+00 1.960000e-04 1.000000e+00 1.970000e-04 1.000000e+00 1.980000e-04 1.000000e+00 1.990000e-04 1.000000e+00)
X1 n1 n8 n7 irf520
D1 n1 n2 DI_1N4007
C1 n2 n11 12e-6
R8 n11 n1 25
R1 n7 0 2
R3 n12 n2 15
VgenPWMVAR n8 0 PWL(0.000000e+00 5.200000e+00 1.000000e-06 5.200000e+00 2.000000e-06 5.200000e+00 3.000000e-06 5.200000e+00 4.000000e-06 5.200000e+00 5.000000e-06 5.200000e+00 6.000000e-06 5.200000e+00 7.000000e-06 5.200000e+00 8.000000e-06 5.200000e+00 9.000000e-06 5.200000e+00 1.000000e-05 5.200000e+00 1.100000e-05 5.200000e+00 1.200000e-05 5.200000e+00 1.300000e-05 5.200000e+00 1.400000e-05 5.200000e+00 1.500000e-05 5.200000e+00 1.600000e-05 5.200000e+00 1.700000e-05 5.200000e+00 1.800000e-05 5.200000e+00 1.900000e-05 5.200000e+00 2.000000e-05 5.200000e+00 2.100000e-05 5.200000e+00 2.200000e-05 5.200000e+00 2.300000e-05 5.200000e+00 2.400000e-05 5.200000e+00 2.500000e-05 5.200000e+00 2.600000e-05 5.200000e+00 2.700000e-05 5.200000e+00 2.800000e-05 5.200000e+00 2.900000e-05 5.200000e+00 3.000000e-05 5.200000e+00 3.100000e-05 5.200000e+00 3.200000e-05 5.200000e+00 3.300000e-05 5.200000e+00 3.400000e-05 5.200000e+00 3.500000e-05 5.200000e+00 3.600000e-05 5.200000e+00 3.700000e-05 5.200000e+00 3.800000e-05 5.200000e+00 3.900000e-05 5.200000e+00 4.000000e-05 5.200000e+00 4.100000e-05 5.200000e+00 4.200000e-05 5.200000e+00 4.300000e-05 5.200000e+00 4.400000e-05 5.200000e+00 4.500000e-05 5.200000e+00 4.600000e-05 5.200000e+00 4.700000e-05 5.200000e+00 4.800000e-05 5.200000e+00 4.900000e-05 5.200000e+00 5.000000e-05 5.200000e+00 5.100000e-05 5.200000e+00 5.200000e-05 5.200000e+00 5.300000e-05 5.200000e+00 5.400000e-05 5.200000e+00 5.500000e-05 5.200000e+00 5.600000e-05 5.200000e+00 5.700000e-05 5.200000e+00 5.800000e-05 5.200000e+00 5.900000e-05 5.200000e+00 6.000000e-05 5.200000e+00 6.100000e-05 5.200000e+00 6.200000e-05 5.200000e+00 6.300000e-05 5.200000e+00 6.400000e-05 5.200000e+00 6.500000e-05 5.200000e+00 6.600000e-05 5.200000e+00 6.700000e-05 5.200000e+00 6.800000e-05 5.200000e+00 6.900000e-05 5.200000e+00 7.000000e-05 5.200000e+00 7.100000e-05 5.200000e+00 7.200000e-05 5.200000e+00 7.300000e-05 5.200000e+00 7.400000e-05 5.200000e+00 7.500000e-05 5.200000e+00 7.600000e-05 5.200000e+00 7.700000e-05 5.200000e+00 7.800000e-05 5.200000e+00 7.900000e-05 5.200000e+00 8.000000e-05 5.200000e+00 8.100000e-05 5.200000e+00 8.200000e-05 5.200000e+00 8.300000e-05 5.200000e+00 8.400000e-05 5.200000e+00 8.500000e-05 5.200000e+00 8.600000e-05 5.200000e+00 8.700000e-05 5.200000e+00 8.800000e-05 5.200000e+00 8.900000e-05 5.200000e+00 9.000000e-05 5.200000e+00 9.100000e-05 5.200000e+00 9.200000e-05 5.200000e+00 9.300000e-05 5.200000e+00 9.400000e-05 5.200000e+00 9.500000e-05 5.200000e+00 9.600000e-05 5.200000e+00 9.700000e-05 5.200000e+00 9.800000e-05 5.200000e+00 9.900000e-05 5.200000e+00 1.000000e-04 5.200000e+00 1.010000e-04 5.200000e+00 1.020000e-04 5.200000e+00 1.030000e-04 5.200000e+00 1.040000e-04 5.200000e+00 1.050000e-04 5.200000e+00 1.060000e-04 5.200000e+00 1.070000e-04 5.200000e+00 1.080000e-04 5.200000e+00 1.090000e-04 5.200000e+00 1.100000e-04 5.200000e+00 1.110000e-04 5.200000e+00 1.120000e-04 5.200000e+00 1.130000e-04 5.200000e+00 1.140000e-04 5.200000e+00 1.150000e-04 5.200000e+00 1.160000e-04 5.200000e+00 1.170000e-04 5.200000e+00 1.180000e-04 5.200000e+00 1.190000e-04 5.200000e+00 1.200000e-04 5.200000e+00 1.210000e-04 5.200000e+00 1.220000e-04 5.200000e+00 1.230000e-04 5.200000e+00 1.240000e-04 5.200000e+00 1.250000e-04 5.200000e+00 1.260000e-04 5.200000e+00 1.270000e-04 5.200000e+00 1.280000e-04 5.200000e+00 1.290000e-04 5.200000e+00 1.300000e-04 5.200000e+00 1.310000e-04 5.200000e+00 1.320000e-04 5.200000e+00 1.330000e-04 5.200000e+00 1.340000e-04 5.200000e+00 1.350000e-04 5.200000e+00 1.360000e-04 5.200000e+00 1.370000e-04 5.200000e+00 1.380000e-04 5.200000e+00 1.390000e-04 5.200000e+00 1.400000e-04 5.200000e+00 1.410000e-04 5.200000e+00 1.420000e-04 5.200000e+00 1.430000e-04 5.200000e+00 1.440000e-04 5.200000e+00 1.450000e-04 5.200000e+00 1.460000e-04 5.200000e+00 1.470000e-04 5.200000e+00 1.480000e-04 5.200000e+00 1.490000e-04 5.200000e+00 1.500000e-04 5.200000e+00 1.510000e-04 5.200000e+00 1.520000e-04 5.200000e+00 1.530000e-04 5.200000e+00 1.540000e-04 5.200000e+00 1.550000e-04 5.200000e+00 1.560000e-04 5.200000e+00 1.570000e-04 5.200000e+00 1.580000e-04 5.200000e+00 1.590000e-04 5.200000e+00 1.600000e-04 5.200000e+00 1.610000e-04 5.200000e+00 1.620000e-04 5.200000e+00 1.630000e-04 5.200000e+00 1.640000e-04 5.200000e+00 1.650000e-04 5.200000e+00 1.660000e-04 5.200000e+00 1.670000e-04 5.200000e+00 1.680000e-04 5.200000e+00 1.690000e-04 5.200000e+00 1.700000e-04 5.200000e+00 1.710000e-04 5.200000e+00 1.720000e-04 5.200000e+00 1.730000e-04 5.200000e+00 1.740000e-04 5.200000e+00 1.750000e-04 5.200000e+00 1.760000e-04 5.200000e+00 1.770000e-04 5.200000e+00 1.780000e-04 5.200000e+00 1.790000e-04 5.200000e+00 1.800000e-04 5.200000e+00 1.810000e-04 5.200000e+00 1.820000e-04 5.200000e+00 1.830000e-04 5.200000e+00 1.840000e-04 5.200000e+00 1.850000e-04 5.200000e+00 1.860000e-04 5.200000e+00 1.870000e-04 5.200000e+00 1.880000e-04 5.200000e+00 1.890000e-04 5.200000e+00 1.900000e-04 5.200000e+00 1.910000e-04 5.200000e+00 1.920000e-04 5.200000e+00 1.930000e-04 5.200000e+00 1.940000e-04 5.200000e+00 1.950000e-04 5.200000e+00 1.960000e-04 5.200000e+00 1.970000e-04 5.200000e+00 1.980000e-04 5.200000e+00 1.990000e-04 5.200000e+00)
R2 n8 0 10e3
VMos1 n9 0 25
L25 n3 0 1e-6

.param parLaC=2.000000e-03
.param parRaC=6.910000e+01
.ic

**********MODELS**********
*****MODEL1*****
.model SW1 SW(Ron=0.1 Roff=1Meg Vt=.5 Vh=0)
*****MODEL2*****
.MODEL DI_1N4007 D  ( IS=76.9p RS=42.0m BV=1.00k IBV=5.00u
+ CJO=26.5p  M=0.333 N=1.45 TT=4.32u )
*****MODEL3*****
.SUBCKT irf520 1 2 3
**************************************
*      Model Generated by MODPEX     *
*Copyright(c) Symmetry Design Systems*
*         All Rights Reserved        *
*    UNPUBLISHED LICENSED SOFTWARE   *
*   Contains Proprietary Information *
*      Which is The Property of      *
*     SYMMETRY OR ITS LICENSORS      *
*Commercial Use or Resale Restricted *
*   by Symmetry License Agreement    *
**************************************
* Model generated on Apr 24, 96
* Model format: SPICE3
* Symmetry POWER MOS Model (Version 1.0)
* External Node Designations
* Node 1 -> Drain
* Node 2 -> Gate
* Node 3 -> Source
M1 9 7 8 8 MM L=100u W=100u
* Default values used in MM:
* The voltage-dependent capacitances are
* not included. Other default values are:
*   RS=0 RD=0 LD=0 CBD=0 CBS=0 CGBO=0
.MODEL MM NMOS LEVEL=1 IS=1e-32
+VTO=3.61397 LAMBDA=0.00572642 KP=3.9143
+CGSO=3.28344e-06 CGDO=1.0112e-11
RS 8 3 0.171045
D1 3 1 MD
.MODEL MD D IS=7.10668e-11 RS=0.0302634 N=1.21428 BV=100
+IBV=0.00025 EG=1 XTI=2.99378 TT=2.27818e-09
+CJO=5.01988e-10 VJ=0.565258 M=0.378444 FC=0.5
RDS 3 1 4e+06
RD 9 1 0.01473
RG 2 7 1.34402
D2 4 5 MD1
* Default values used in MD1:
*   RS=0 EG=1.11 XTI=3.0 TT=0
*   BV=infinite IBV=1mA
.MODEL MD1 D IS=1e-32 N=50
+CJO=4.14565e-10 VJ=0.5 M=0.640575 FC=1e-08
D3 0 5 MD2
* Default values used in MD2:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   BV=infinite IBV=1mA
.MODEL MD2 D IS=1e-10 N=0.4 RS=3e-06
RL 5 10 1
FI2 7 9 VFI2 -1
VFI2 4 0 0
EV16 10 0 9 7 1
CAP 11 10 6.23795e-10
FI1 7 9 VFI1 -1
VFI1 11 6 0
RCAP 6 10 1
D4 0 6 MD3
* Default values used in MD3:
*   EG=1.11 XTI=3.0 TT=0 CJO=0
*   RS=0 BV=infinite IBV=1mA
.MODEL MD3 D IS=1e-10 N=0.4
.ENDS
